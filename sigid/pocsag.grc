<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>pocsag</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/argilo/Documents/bso2019/sigid/pocsag.dat</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>mixalot_pocencode</key>
<param><key>id</key><value>mixalot_pocencode_0</value></param>
<param><key>baudrate</key><value>1200</value></param>
<param><key>capcode</key><value>123456</value></param>
<param><key>type</key><value>1</value></param>
<param><key>msg</key><value>Signal identification challenge #12: flag{b4cK_to_pag3_0n3}</value></param>
<param><key>symrate</key><value>38400</value></param>
</block>
<connection><source_block_id>mixalot_pocencode_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
